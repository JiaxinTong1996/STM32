# Keil uVision project InclineTooling_ATC.uvprojx, settings and files
target InclineTooling_ATC (ARM-ADS)
  device: STM32F207VE STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: InclineTooling_ATC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c include: ../Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F2xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User
    ../Src/: stm32f2xx_it.c main.c usart.c stm32f2xx_hal_msp.c dma.c adc.c gpio.c tim.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_adc.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_gpio.c stm32f2xx_hal.c stm32f2xx_hal_uart.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_flash.c
software components: CMSIS:CORE 4.3.0
